# Keil uVision project multifunction car.uvproj, settings and files
target IK-STC15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TM1637 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source;..\User
  group USER
    ../User/: main.c
  group SOURCE
    ../Source/: delay.c ps2.c beep.c
